## kernel_ipu/Kconfig
```kconfig
config IPU
	tristate "IPU DEVICE Driver"
	default y
	help
	This is ipu device driver for android system.
```
